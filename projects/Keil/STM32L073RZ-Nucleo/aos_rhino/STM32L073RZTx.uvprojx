# Keil uVision project STM32L073RZTx.uvprojx, settings and files
target STM32L073RZTx (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32L073RZTx STMicroelectronics
  pack: Keil.STM32L0xx_DFP.1.6.0
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x802FFFF) CLOCK(8000000) CPUTYPE("Cortex-M0+")
  output: STM32L073RZTx
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=1
  c define: USE_FULL_LL_DRIVER,STM32L073xx,AOS_KV,USE_B_EML3047,CONFIG_LINKWAN,REGION_CN470
  c misc: --C99 -DSYSINFO_OS_VERSION=\"APP-1.0.0\" -DSYSINFO_PRODUCT_MODEL=\"ALI_AOS_STM32L073RZTx\" -DSYSINFO_DEVICE_NAME=\"STM32L073RZTx\" -DSYSINFO_KERNEL_VERSION=\"AOS-R-1.3.2\" -DSYSINFO_APP_VERSION=\"APP-1.0.0\" -DSTDIO_UART=0 -DCONFIG_NO_TCPIP -DRHINO_CONFIG_TICK_TASK=0 -DCONFIG_AOS_KV_MULTIPTN_MODE -DCONFIG_AOS_KV_PTN=6 -DCONFIG_AOS_KV_SECOND_PTN=7 -DCONFIG_AOS_KV_PTN_SIZE=4096 -DCONFIG_AOS_KV_BUFFER_SIZE=8192 -D__BSD_VISIBLE -DRHINO_CONFIG_TICK_TASK=0
  c include: ..\..\..\..\include;..\..\..\..\kernel\rhino\core\include;..\..\..\..\platform\arch\arm\armv6m\armcc\m0;..\..\..\..\platform\mcu\stm32l0xx\Drivers\STM32L0xx_HAL_Driver\Inc;..\..\..\..\platform\mcu\stm32l0xx\Drivers\STM32L0xx_HAL_Driver\Inc\Legacy;..\..\..\..\platform\mcu\stm32l0xx\Drivers\CMSIS\Device\ST\STM32L0xx\Include;..\..\..\..\platform\mcu\stm32l0xx\Drivers\CMSIS\Include;..\..\..\..\platform\mcu\stm32l0xx\src\STM32L073RZ-Nucleo\aos_rhino;..\..\..\..\include\hal;..\..\..\..\kernel\modules\fs\kv\include;..\..\..\..\kernel\vcall\aos;..\..\..\..\utility\libc\compilers\armlibc;..\..\..\..\kernel\vfs\include;..\..\..\..\board\eml3047;..\..\..\..\board\eml3047\inc;..\..\..\..\device\lora\eml3047_lrwan;..\..\..\..\device\lora\sx1276;..\..\..\..\kernel\protocols\lorawan;..\..\..\..\kernel\protocols\lorawan\linkwan\include;..\..\..\..\kernel\protocols\lorawan\lora\mac;..\..\..\..\kernel\protocols\lorawan\lora\radio;..\..\..\..\kernel\protocols\lorawan\lora\system;..\..\..\..\kernel\protocols\lorawan\linkwan\region;..\..\..\..\kernel\protocols\lorawan\lora\mac\region;..\..\..\..\kernel\protocols\lorawan\lora\system\crypto;..\..\..\..\platform\mcu\stm32l0xx\Drivers\STM32L0xx_HAL_Driver\Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x30000
  memory RVCT9: RAM 0x20000000 size 0x5000
  link misc: --diag_suppress=L6329
  group platform\mcu\stm32l0xx\src\STM32L073RZ-Nucleo
    ../../../../platform/mcu/stm32l0xx/src/STM32L073RZ-Nucleo/aos_rhino/: stm32l0xx_it.c system_stm32l0xx.c soc_init.c
    ../../../../platform/mcu/stm32l0xx/src/STM32L073RZ-Nucleo/: startup_stm32l073xx_keil.s
  group platform\mcu\stm32l0xx\src\STM32L073RZ-Nucleo\hal
    ../../../../platform/mcu/stm32l0xx/src/STM32L073RZ-Nucleo/hal/: flash_port.c
  group kernel\rhino\core
    ../../../../kernel/rhino/core/: k_buf_queue.c k_dyn_mem_proc.c k_err.c k_event.c k_idle.c k_mm.c k_mm_blk.c k_mm_debug.c k_mutex.c k_obj.c k_pend.c k_queue.c k_ringbuf.c k_sched.c k_sem.c k_stats.c k_sys.c k_task.c k_task_sem.c k_tick.c k_time.c k_timer.c k_workqueue.c
  group platform\mcu\stm32l0xx\aos
    ../../../../platform/mcu/stm32l0xx/aos/: soc_impl.c
  group platform\arch\arm\armv6m\armcc\m0
    ../../../../platform/arch/arm/armv6m/armcc/m0/: port_c.c port_s.S
  group utility\libc\compilers\armlibc
    ../../../../utility/libc/compilers/armlibc/: armcc_libc.c
  group kernel\modules\fs\kv
    ../../../../kernel/modules/fs/kv/: kvmgr.c
  group kernel\vcall
    ../../../../platform/mcu/stm32l0xx/src/STM32L073RZ-Nucleo/aos_rhino/: aos_rhino_kv.c
  group example
    ../../../../example/lorawan/linkwan/: linkwan.c
    ../../../../platform/mcu/stm32l0xx/src/STM32L071KB/runapp/: main.c
  group kernel\vfs
    ../../../../kernel/vfs/: vfs.c vfs_file.c vfs_inode.c
  group device\lora
    ../../../../device/lora/sx1276/: sx1276.c
    ../../../../device/lora/eml3047_lrwan/: eml3047.c
  group board\eml3047
    ../../../../board/eml3047/: board.c
    ../../../../board/eml3047/src/: debug.c eml3047_hw.c eml3047_it.c hw_gpio.c hw_rtc.c hw_spi.c lorawan_port.c vcom.c
  group kernal\protocols\lorawan\lora
    ../../../../kernel/protocols/lorawan/linkwan/: linkwan.c linkwan_at.c
    ../../../../kernel/protocols/lorawan/linkwan/region/: RegionCN470A.c
    ../../../../kernel/protocols/lorawan/lora/mac/: LoRaMac.c LoRaMacCrypto.c
    ../../../../kernel/protocols/lorawan/lora/mac/region/: Region.c RegionAS923.c RegionAU915.c RegionCN470.c RegionCN779.c RegionCommon.c RegionEU433.c RegionEU868.c RegionIN865.c RegionKR920.c RegionUS915.c RegionUS915-Hybrid.c
    ../../../../kernel/protocols/lorawan/lora/system/: delay.c low_power.c timeServer.c utilities.c
    ../../../../kernel/protocols/lorawan/lora/system/crypto/: aes.c cmac.c
  group platform\mcu\drivers
    ../../../../platform/mcu/stm32l0xx/Drivers/STM32L0xx_HAL_Driver/Src/: stm32l0xx_hal.c stm32l0xx_hal_adc.c stm32l0xx_hal_adc_ex.c stm32l0xx_hal_comp.c stm32l0xx_hal_comp_ex.c stm32l0xx_hal_cortex.c stm32l0xx_hal_crc.c stm32l0xx_hal_crc_ex.c stm32l0xx_hal_cryp.c stm32l0xx_hal_cryp_ex.c stm32l0xx_hal_dac.c stm32l0xx_hal_dac_ex.c stm32l0xx_hal_dma.c stm32l0xx_hal_firewall.c stm32l0xx_hal_flash.c stm32l0xx_hal_flash_ex.c stm32l0xx_hal_flash_ramfunc.c stm32l0xx_hal_gpio.c stm32l0xx_hal_i2c.c stm32l0xx_hal_i2c_ex.c stm32l0xx_hal_i2s.c stm32l0xx_hal_irda.c stm32l0xx_hal_iwdg.c stm32l0xx_hal_lcd.c stm32l0xx_hal_lptim.c stm32l0xx_hal_msp_template.c stm32l0xx_hal_pcd.c stm32l0xx_hal_pcd_ex.c stm32l0xx_hal_pwr.c stm32l0xx_hal_pwr_ex.c stm32l0xx_hal_rcc.c stm32l0xx_hal_rcc_ex.c stm32l0xx_hal_rng.c stm32l0xx_hal_rtc.c stm32l0xx_hal_rtc_ex.c stm32l0xx_hal_smartcard.c stm32l0xx_hal_smartcard_ex.c stm32l0xx_hal_smbus.c stm32l0xx_hal_spi.c stm32l0xx_hal_tim.c stm32l0xx_hal_tim_ex.c stm32l0xx_hal_tsc.c stm32l0xx_hal_uart.c stm32l0xx_hal_uart_ex.c stm32l0xx_hal_usart.c stm32l0xx_hal_wwdg.c stm32l0xx_ll_adc.c stm32l0xx_ll_comp.c stm32l0xx_ll_crc.c stm32l0xx_ll_crs.c stm32l0xx_ll_dac.c stm32l0xx_ll_dma.c stm32l0xx_ll_exti.c stm32l0xx_ll_gpio.c stm32l0xx_ll_i2c.c stm32l0xx_ll_lptim.c stm32l0xx_ll_lpuart.c stm32l0xx_ll_pwr.c stm32l0xx_ll_rcc.c stm32l0xx_ll_rng.c stm32l0xx_ll_rtc.c stm32l0xx_ll_spi.c stm32l0xx_ll_tim.c stm32l0xx_ll_usart.c stm32l0xx_ll_utils.c
software components: CMSIS:CORE 4.1.0
